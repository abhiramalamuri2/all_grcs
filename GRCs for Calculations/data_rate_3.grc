options:
  parameters:
    author: aerolifi
    generate_options: qt_gui
    id: data_rate_3
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 32e3
  states: {}
- name: usrp_gain
  id: variable
  parameters:
    value: '0'
  states: {}
- name: usrp_samp_rate
  id: variable
  parameters:
    value: '0'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_complex_to_interleaved_char_0
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: '1.0'
    vector_output: 'False'
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_sink_1_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: byte
  states: {}
- name: epy_block_0_1_0_1_0
  id: epy_block
  parameters:
    _source_code: "#Transmitter: Only timestamp and data rate\nimport numpy as np\nfrom gnuradio import gr\nimport os\nimport time\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block - calculates data rate every 5 seconds\"\"\"\n\n    def __init__(self, example_param=1.0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Embedded Python Block',   # will show up in GRC\n            in_sig=[np.byte],\n            out_sig=[np.byte]\n        )\n        self.example_param = example_param\n        self.byte_count = 0\n        self.start_time = time.time()\n\n    def work(self, input_items, output_items):\n        \"\"\"Calculate and print the data rate every 5 seconds\"\"\"\n\n        # Count the number of bytes received in this work call\n        self.byte_count += len(input_items[0])\n\n        # Check the time elapsed since the start of the 5-second interval\n        current_time = time.time()\n        elapsed_time = current_time - self.start_time\n\n        if elapsed_time >= 1.0:  # Every 5 seconds\n            data_rate = self.byte_count / elapsed_time  # Calculate data rate in bytes per second\n            timestamp = time.strftime('%Y-%m-%d %H:%M:%S')\n            \n            # Print the data rate with the current timestamp\n            os.system('echo \"{} Data Rate: {:.2f} bytes/sec\" > /dev/pts/6'.format(timestamp, data_rate))\n            \n            # Reset the byte count and start time for the next interval\n            self.byte_count = 0\n            self.start_time = current_time\n\n        output_items[0][:] = input_items[0]  # Pass through the input to the output\n        return len(output_items[0])  # Return the length of the output\n\n"
    example_param: '1.0'
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: A
    bw0: 10e6
    center_freq0: 19e06
    dev_addr: ''
    gain0: usrp_gain
    samp_rate: usrp_samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: A
    bw0: 10e6
    center_freq0: 19e06
    gain0: usrp_gain
    samp_rate: usrp_samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: channel
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: channel
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '0']
- [analog_const_source_x_1, '0', blocks_float_to_complex_0, '1']
- [blocks_complex_to_interleaved_char_0, '0', blocks_probe_rate_0, '0']
- [blocks_complex_to_interleaved_char_0, '0', epy_block_0_1_0_1_0, '0']
- [blocks_float_to_complex_0, '0', uhd_usrp_sink_0, '0']
- [blocks_float_to_complex_0, '0', virtual_sink_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [epy_block_0_1_0_1_0, '0', blocks_null_sink_1_0_0_0_0, '0']
- [uhd_usrp_source_0, '0', blocks_complex_to_interleaved_char_0, '0']
- [uhd_usrp_source_0, '0', blocks_probe_rate_0, '0']
- [virtual_source_0, '0', blocks_complex_to_interleaved_char_0, '0']

metadata:
  file_format: 1
