options:
  parameters:
    generate_options: hb
    id: new_hier
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/aerolifi/Documents/GRCs/nodata.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/aerolifi/Documents/GRCs/nodata.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: len_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_1_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: len_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: digital_ofdm_tx_0_0_1
  id: digital_ofdm_tx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-4,-3,-2,-1,1,2,3,4),)
    packet_len_key: len_tag_key
    payload_mod: '"QPSK"'
    pilot_carriers: ((-6,-5,5,6),)
    pilot_symbols: ((-1,1,-1,1),)
    rolloff: '0'
    sync_word1: None
    sync_word2: None
  states: {}
- name: digital_ofdm_tx_0_0_1_0
  id: digital_ofdm_tx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-4,-3,-2,-1,1,2,3,4),)
    packet_len_key: len_tag_key
    payload_mod: '"QPSK"'
    pilot_carriers: ((-6,-5,5,6),)
    pilot_symbols: ((-1,1,-1,1),)
    rolloff: '0'
    sync_word1: None
    sync_word2: None
  states: {}
- name: digital_ofdm_tx_0_1
  id: digital_ofdm_tx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-8,-7,-6,-5,5,6,7,8),)
    packet_len_key: len_tag_key
    payload_mod: '"QPSK"'
    pilot_carriers: ((-4,-3,3,4),)
    pilot_symbols: ((-1,1,-1,1),)
    rolloff: '0'
    sync_word1: None
    sync_word2: None
  states: {}
- name: digital_ofdm_tx_0_1_0
  id: digital_ofdm_tx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-8,-7,-6,-5,5,6,7,8),)
    packet_len_key: len_tag_key
    payload_mod: '"QPSK"'
    pilot_carriers: ((-4,-3,3,4),)
    pilot_symbols: ((-1,1,-1,1),)
    rolloff: '0'
    sync_word1: None
    sync_word2: None
  states: {}
- name: fft_len
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: len_tag_key
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: packet_len
  id: parameter
  parameters:
    value: '0'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: out
    type: complex
  states: {}

connections:
- [blocks_file_source_0_0_0, '0', blocks_stream_to_tagged_stream_0_1, '0']
- [blocks_file_source_0_0_0, '0', digital_ofdm_tx_0_1, '0']
- [blocks_file_source_0_0_0_0, '0', blocks_stream_to_tagged_stream_0_1_0, '0']
- [blocks_file_source_0_0_0_0, '0', digital_ofdm_tx_0_1_0, '0']
- [blocks_stream_to_tagged_stream_0_1, '0', digital_ofdm_tx_0_0_1, '0']
- [blocks_stream_to_tagged_stream_0_1_0, '0', digital_ofdm_tx_0_0_1_0, '0']
- [digital_ofdm_tx_0_0_1, '0', pad_sink_0, '0']
- [digital_ofdm_tx_0_1, '0', pad_sink_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
