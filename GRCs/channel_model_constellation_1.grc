options:
  parameters:
    author: aerolifi
    generate_options: qt_gui
    id: channel_model_constellation_1
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: magnitude
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.25'
  states: {state: disabled}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '0.5'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '256000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: variable_constellation_1
    modulus: '8'
    step_size: '.0005'
    type: cma
  states: {}
- name: variable_constellation_1
  id: variable_constellation
  parameters:
    const_points: '[1, -1]'
    precision: '8'
    sym_map: '[0,1]'
    type: qpsk
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /dev/pts/0
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/aerolifi/Documents/GRCs/file.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters:
    en_uvec: 'False'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: complex
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: byte
  states: {}
- name: blocks_repack_bits_bb_0_0_0
  id: blocks_repack_bits_bb
  parameters:
    comment: Tagged Stream to PDU block up ahead needs packed bytes
    endianness: gr.GR_MSB_FIRST
    k: '1'
    l: '8'
    len_tag_key: '"packet_len"'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '1'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    comment: Append header to payload
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0_0_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '2'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: noise
    seed: '0'
    taps: '1.0'
  states: {state: disabled}
- name: digital_constellation_decoder_cb_1_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: variable_constellation_1
  states: {}
- name: digital_constellation_modulator_0_0
  id: digital_constellation_modulator
  parameters:
    constellation: variable_constellation_1
    differential: 'False'
    excess_bw: '0.35'
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_1
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: digital.packet_utils.default_access_code
    comment: Correlates with access code to extract the payload.
    tagname: '"packet_len"'
    threshold: '0'
    type: byte
  states: {}
- name: digital_costas_loop_cc_2_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    use_snr: 'True'
    w: '0.0628'
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: variable_adaptive_algorithm_0
    num_taps: '8'
    sps: '1'
  states: {}
- name: digital_pfb_clock_sync_xxx_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: '0.0628'
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), 0.35, 11*sps*nfilts)
    type: ccf
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    comment: Generate header
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import os


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """Print the signal power in dB to /dev/pts"""
              power_db = 10 * np.log10(np.mean(np.abs(input_items[0])**2))  # Compute power in dB
              os.system('echo "{:.2f}" > /dev/pts/4'.format(power_db))  # Write to /dev/pts/4
              output_items[0][:] = input_items[0]  # Pass through the input to the output
              return len(output_items[0])  # Return the length of the output
    example_param: '1.0'
  states: {state: disabled}
- name: hdr_format
  id: parameter
  parameters:
    label: Header Formatter
    value: digital.header_format_default(digital.packet_utils.default_access_code, 0)
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: Recovered Signal
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: Before Channel
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"OFE 0 Signal Power"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: A
    bw0: 1e6
    center_freq0: 25e06
    dev_addr: ''
    gain0: '40'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: A
    bw0: 1e06
    center_freq0: 25e06
    gain0: '40'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: chan
  states: {state: disabled}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: chan
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_multiply_const_vxx_0, '0', channels_channel_model_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_repack_bits_bb_0_0_0, '0', blocks_file_sink_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_mux_0, '1']
- [blocks_stream_to_tagged_stream_0, '0', digital_protocol_formatter_bb_0, '0']
- [blocks_tagged_stream_mux_0, '0', blocks_probe_rate_0, '0']
- [blocks_tagged_stream_mux_0, '0', digital_constellation_modulator_0_0, '0']
- [blocks_unpack_k_bits_bb_0_0_0, '0', digital_correlate_access_code_xx_ts_1, '0']
- [channels_channel_model_0, '0', virtual_sink_0, '0']
- [digital_constellation_decoder_cb_1_0, '0', blocks_unpack_k_bits_bb_0_0_0, '0']
- [digital_constellation_modulator_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_correlate_access_code_xx_ts_1, '0', blocks_repack_bits_bb_0_0_0, '0']
- [digital_costas_loop_cc_2_0, '0', digital_linear_equalizer_0, '0']
- [digital_linear_equalizer_0, '0', digital_constellation_decoder_cb_1_0, '0']
- [digital_linear_equalizer_0, '0', epy_block_0, '0']
- [digital_linear_equalizer_0, '0', qtgui_const_sink_x_0, '0']
- [digital_linear_equalizer_0, '0', qtgui_freq_sink_x_1, '0']
- [digital_pfb_clock_sync_xxx_0, '0', digital_costas_loop_cc_2_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0_0, '0']
- [uhd_usrp_source_0, '0', digital_pfb_clock_sync_xxx_0, '0']
- [virtual_source_0, '0', digital_pfb_clock_sync_xxx_0, '0']

metadata:
  file_format: 1
