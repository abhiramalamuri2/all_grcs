options:
  parameters:
    author: aerolifi
    generate_options: qt_gui
    id: ofdm_demod_integrated_multi_channel_22
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: len_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '64000'
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /dev/pts/2
    type: byte
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: /dev/pts/3
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0_0_0_0
  id: blocks_file_sink
  parameters:
    file: /dev/pts/3
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/aerolifi/Documents/GRCs/file1.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/aerolifi/Documents/GRCs/file2.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_0_0
  id: blocks_file_source
  parameters:
    file: /home/aerolifi/Documents/GRCs/file.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_1
  id: blocks_file_source
  parameters:
    file: /home/aerolifi/Documents/GRCs/file.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.05'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.05'
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: len_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: len_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: len_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_1
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: len_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: digital_ofdm_rx_0
  id: digital_ofdm_rx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-8,-7,-6,-5,5,6,7,8),)
    packet_len_key: '"rx_len"'
    payload_mod: '"QPSK"'
    pilot_carriers: ((-4,-3,3,4),)
    pilot_symbols: ((-1,1,-1,1),)
    sync_word1: None
    sync_word2: None
  states: {state: disabled}
- name: digital_ofdm_rx_0_0
  id: digital_ofdm_rx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-4,-3,-2,-1,1,2,3,4),)
    packet_len_key: '"rx_len"'
    payload_mod: '"QPSK"'
    pilot_carriers: ((-6,-5,5,6),)
    pilot_symbols: ((-1,1,-1,1),)
    sync_word1: None
    sync_word2: None
  states: {state: disabled}
- name: digital_ofdm_rx_0_0_0
  id: digital_ofdm_rx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-4,-3,-2,-1,1,2,3,4),)
    packet_len_key: '"rx_len"'
    payload_mod: '"QPSK"'
    pilot_carriers: ((-6,-5,5,6),)
    pilot_symbols: ((-1,1,-1,1),)
    sync_word1: None
    sync_word2: None
  states: {}
- name: digital_ofdm_rx_0_1
  id: digital_ofdm_rx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-8,-7,-6,-5,5,6,7,8),)
    packet_len_key: '"rx_len"'
    payload_mod: '"QPSK"'
    pilot_carriers: ((-4,-3,3,4),)
    pilot_symbols: ((-1,1,-1,1),)
    sync_word1: None
    sync_word2: None
  states: {}
- name: digital_ofdm_tx_0
  id: digital_ofdm_tx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-8,-7,-6,-5,5,6,7,8),)
    packet_len_key: len_tag_key
    payload_mod: '"QPSK"'
    pilot_carriers: ((-4,-3,3,4),)
    pilot_symbols: ((-1,1,-1,1),)
    rolloff: '0'
    sync_word1: None
    sync_word2: None
  states: {}
- name: digital_ofdm_tx_0_0
  id: digital_ofdm_tx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-4,-3,-2,-1,1,2,3,4),)
    packet_len_key: len_tag_key
    payload_mod: '"QPSK"'
    pilot_carriers: ((-6,-5,5,6),)
    pilot_symbols: ((-1,1,-1,1),)
    rolloff: '0'
    sync_word1: None
    sync_word2: None
  states: {}
- name: digital_ofdm_tx_0_0_0
  id: digital_ofdm_tx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-4,-3,-2,-1,1,2,3,4),)
    packet_len_key: len_tag_key
    payload_mod: '"QPSK"'
    pilot_carriers: ((-6,-5,5,6),)
    pilot_symbols: ((-1,1,-1,1),)
    rolloff: '0'
    sync_word1: None
    sync_word2: None
  states: {}
- name: digital_ofdm_tx_0_1
  id: digital_ofdm_tx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-8,-7,-6,-5,5,6,7,8),)
    packet_len_key: len_tag_key
    payload_mod: '"QPSK"'
    pilot_carriers: ((-4,-3,3,4),)
    pilot_symbols: ((-1,1,-1,1),)
    rolloff: '0'
    sync_word1: None
    sync_word2: None
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import os


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """Print the signal power in dB to /dev/pts"""
              power_db = 10 * np.log10(np.mean(np.abs(input_items[0])**2))  # Compute power in dB
              os.system('echo "{:.2f}" > /dev/pts/4'.format(power_db))  # Write to /dev/pts/4
              output_items[0][:] = input_items[0]  # Pass through the input to the output
              return len(output_items[0])  # Return the length of the output
    example_param: '1.0'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import os


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """Print the signal power in dB to /dev/pts"""
              power_db = 10 * np.log10(np.mean(np.abs(input_items[0])**2))  # Compute power in dB
              os.system('echo "{:.2f}" > /dev/pts/1'.format(power_db))  # Write to /dev/pts/5
              output_items[0][:] = input_items[0]  # Pass through the input to the output
              return len(output_items[0])  # Return the length of the output
    example_param: '1.0'
  states: {}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import os


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.complex64, np.complex64, np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """Print the signal power in dB to /dev/pts"""
              power_db_0 = 10 * np.log10(np.mean(np.abs(input_items[0])**2))  # Compute power of input 0 in dB
              power_db_1 = 10 * np.log10(np.mean(np.abs(input_items[1])**2))  # Compute power of input 1 in dB
              #os.system('echo "{:.2f}" > /dev/pts/4'.format(power_db))  # Write to /dev/pts/4
              if power_db_0 > power_db_1:
              	output_items[0][:] = input_items[0]
              	#output_items[1][:] = 0
              else:
              	output_items[0][:] = input_items[2]
              	#output_items[1][:] = input_items[1]

              	  # Pass through the input 1 to the output
              #os.system('echo "{:.2f}" > /dev/pts/6'.format(file_data))	
                # Pass through the input 0 to the output
              return len(output_items[0])  # Return the length of the output
    example_param: '1.0'
  states: {}
- name: epy_block_0_1_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import os


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.complex64, np.complex64, np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """Print the signal power in dB to /dev/pts"""
              power_db_0 = 10 * np.log10(np.mean(np.abs(input_items[0])**2))  # Compute power of input 0 in dB
              power_db_1 = 10 * np.log10(np.mean(np.abs(input_items[1])**2))  # Compute power of input 1 in dB
              #os.system('echo "{:.2f}" > /dev/pts/4'.format(power_db))  # Write to /dev/pts/4
              if power_db_0 <= power_db_1:
              	output_items[0][:] = input_items[1]
              	#output_items[1][:] = 0
              else:
              	output_items[0][:] = input_items[2]
              	#output_items[1][:] = input_items[1]

              	  # Pass through the input 1 to the output
              #os.system('echo "{:.2f}" > /dev/pts/6'.format(file_data))	
                # Pass through the input 0 to the output
              return len(output_items[0])  # Return the length of the output
    example_param: '1.0'
  states: {}
- name: epy_block_2
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              os.system('echo "{:.2f}" > /dev/pts/5'.format(in_sig[0]))
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    example_param: '1.0'
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: Rx Spectrum
    name: Rx Spectrum 0
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: Rx Spectrum
    name: Rx Spectrum 1
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"OFE 0 Signal Power"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"OFE 1 Signal Power"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: A
    ant1: A
    bw0: 1e6
    bw1: 1e6
    center_freq0: 19e06
    center_freq1: 20e06
    dev_addr: ''
    gain0: '40'
    gain1: '40'
    nchan: '2'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: A
    ant1: A
    bw0: 1e06
    bw1: 1e06
    center_freq0: 19e06
    center_freq1: 20e06
    gain0: '40'
    gain1: '40'
    nchan: '2'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx1
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: tx2
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_file_source_0_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_file_source_0_0_0, '0', blocks_stream_to_tagged_stream_0_1, '0']
- [blocks_file_source_0_1, '0', blocks_stream_to_tagged_stream_0_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', uhd_usrp_sink_0_0, '1']
- [blocks_stream_to_tagged_stream_0, '0', digital_ofdm_tx_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', digital_ofdm_tx_0_0, '0']
- [blocks_stream_to_tagged_stream_0_0_0, '0', digital_ofdm_tx_0_0_0, '0']
- [blocks_stream_to_tagged_stream_0_1, '0', digital_ofdm_tx_0_1, '0']
- [digital_ofdm_rx_0_0, '0', blocks_file_sink_0_0_0, '0']
- [digital_ofdm_rx_0_0_0, '0', blocks_file_sink_0_0_0_0, '0']
- [digital_ofdm_rx_0_1, '0', blocks_file_sink_0_0, '0']
- [digital_ofdm_tx_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_ofdm_tx_0, '0', virtual_sink_0, '0']
- [digital_ofdm_tx_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [digital_ofdm_tx_0_0, '0', virtual_sink_0_0, '0']
- [digital_ofdm_tx_0_0_0, '0', epy_block_0_1_0, '2']
- [digital_ofdm_tx_0_1, '0', epy_block_0_1, '2']
- [epy_block_0, '0', qtgui_time_sink_x_0_0, '0']
- [epy_block_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [epy_block_0_1, '0', digital_ofdm_rx_0_1, '0']
- [epy_block_0_1_0, '0', digital_ofdm_rx_0_0_0, '0']
- [epy_block_2, '0', blocks_null_sink_1, '0']
- [uhd_usrp_source_0, '0', digital_ofdm_rx_0, '0']
- [uhd_usrp_source_0, '0', epy_block_0, '0']
- [uhd_usrp_source_0, '0', epy_block_0_1, '0']
- [uhd_usrp_source_0, '0', epy_block_0_1_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '1', digital_ofdm_rx_0_0, '0']
- [uhd_usrp_source_0, '1', epy_block_0_0, '0']
- [uhd_usrp_source_0, '1', epy_block_0_1, '1']
- [uhd_usrp_source_0, '1', epy_block_0_1_0, '1']
- [uhd_usrp_source_0, '1', qtgui_freq_sink_x_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
