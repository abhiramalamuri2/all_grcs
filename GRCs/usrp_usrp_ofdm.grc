options:
  parameters:
    author: aerolifi
    generate_options: qt_gui
    id: usrp_usrp_ofdm
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: len_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '64000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '256000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: variable_adaptive_algorithm_0
  id: variable_adaptive_algorithm
  parameters:
    cons: variable_constellation_1
    modulus: '2'
    step_size: '.0005'
    type: cma
  states: {}
- name: variable_constellation_1
  id: variable_constellation
  parameters:
    const_points: '[1, -1]'
    precision: '8'
    sym_map: '[0,1]'
    type: bpsk
  states: {}
- name: blocks_file_sink_0_0_1
  id: blocks_file_sink
  parameters:
    file: /dev/pts/2
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/aerolifi/Documents/GRCs/file1.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.25'
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_1_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_null_sink_1_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_1_0_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: len_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate*2
    type: byte
  states: {state: disabled}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_ofdm_rx_0
  id: digital_ofdm_rx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-4,-3,-2,-1,1,2,3,4),)
    packet_len_key: '"rx_len"'
    payload_mod: '"QPSK"'
    pilot_carriers: ((-6,-5,5,6),)
    pilot_symbols: ((-1,1,-1,1),)
    sync_word1: None
    sync_word2: None
  states: {}
- name: digital_ofdm_tx_0
  id: digital_ofdm_tx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-4,-3,-2,-1,1,2,3,4),)
    packet_len_key: len_tag_key
    payload_mod: '"QPSK"'
    pilot_carriers: ((-6,-5,5,6),)
    pilot_symbols: ((-1,1,-1,1),)
    rolloff: '0'
    sync_word1: None
    sync_word2: None
  states: {}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import os


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """Print the signal power in dB to /dev/pts"""
              power_db = 10 * np.log10(np.mean(np.abs(input_items[0])**2))  # Compute power in dB
              os.system('echo "{:.2f}" > /dev/pts/2'.format(power_db))  # Write to /dev/pts/4
              output_items[0][:] = input_items[0]  # Pass through the input to the output
              return len(output_items[0])  # Return the length of the output
    example_param: '1.0'
  states: {state: disabled}
- name: epy_block_0_1_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport os\nimport time\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block - calculates data rate every 5 seconds\"\"\"\n\n    def __init__(self, example_param=1.0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Embedded Python Block',   # will show up in GRC\n            in_sig=[np.byte],\n            out_sig=[np.byte]\n        )\n        self.example_param = example_param\n        self.byte_count = 0\n        self.start_time = time.time()\n\n    def work(self, input_items, output_items):\n        \"\"\"Calculate and print the data rate every 5 seconds\"\"\"\n\n        # Count the number of bytes received in this work call\n        self.byte_count += len(input_items[0])\n        \n        # Convert the list of bytes to characters\n        char_sequence = ''.join([chr(b) for b in input_items[0]])\n\n        # Check the time elapsed since the start of the 5-second interval\n        current_time = time.time()\n        elapsed_time = current_time - self.start_time\n        timestamp = time.strftime('%Y-%m-%d %H:%M:%S')\n        os.system('echo \"{}  Data: {}\" > /dev/pts/1'.format(timestamp, char_sequence))\n\t\n        if elapsed_time >= 1:  # Every 5 seconds\n            data_rate = self.byte_count / elapsed_time  # Calculate data rate in bytes per second\n            os.system('echo \"{}, Data Rate: {:.2f} bytes/sec\" > /dev/pts/3'.format(timestamp, data_rate))\n            \n            # Print the data rate with the current timestamp\n            \n            #os.system('echo \"Data Rate:  bytes/sec, Data: {}\" > /dev/pts/2'.format(char_sequence))\n            \n            # Reset the byte count and start time for the next interval\n            self.byte_count = 0\n            self.start_time = current_time\n\n        output_items[0][:] = input_items[0]  # Pass through the input to the output\n        return len(output_items[0])  # Return the length of the output\n\n"
    example_param: '1.0'
  states: {}
- name: epy_block_0_1_0_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport os\nimport time\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block - calculates data rate every 5 seconds\"\"\"\n\n    def __init__(self, example_param=1.0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Embedded Python Block',   # will show up in GRC\n            in_sig=[np.byte],\n            out_sig=[np.byte]\n        )\n        self.example_param = example_param\n        self.byte_count = 0\n        self.start_time = time.time()\n\n    def work(self, input_items, output_items):\n        \"\"\"Calculate and print the data rate every 5 seconds\"\"\"\n\n        # Count the number of bytes received in this work call\n        self.byte_count += len(input_items[0])\n        \n        # Convert the list of bytes to characters\n        char_sequence = ''.join([chr(b) for b in input_items[0]])\n\n        # Check the time elapsed since the start of the 5-second interval\n        current_time = time.time()\n        elapsed_time = current_time - self.start_time\n\n        if elapsed_time >= 1.0:  # Every 5 seconds\n            data_rate = self.byte_count / elapsed_time  # Calculate data rate in bytes per second\n            timestamp = time.strftime('%Y-%m-%d %H:%M:%S')\n            \n            # Print the data rate with the current timestamp\n            os.system('echo \"{} Data Rate: {:.2f} bytes/sec, Data: {}\" > /dev/pts/2'.format(timestamp, data_rate, char_sequence))\n            #os.system('echo \"Data Rate:  bytes/sec, Data: {}\" > /dev/pts/2'.format(char_sequence))\n            \n            # Reset the byte count and start time for the next interval\n            self.byte_count = 0\n            self.start_time = current_time\n\n        output_items[0][:] = input_items[0]  # Pass through the input to the output\n        return len(output_items[0])  # Return the length of the output\n\n"
    example_param: '1.0'
  states: {state: disabled}
- name: epy_block_0_1_0_1
  id: epy_block
  parameters:
    _source_code: "#Transmitter: Only timestamp and data rate\nimport numpy as np\nfrom gnuradio import gr\nimport os\nimport time\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block - calculates data rate every 5 seconds\"\"\"\n\n    def __init__(self, example_param=1.0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Embedded Python Block',   # will show up in GRC\n            in_sig=[np.byte],\n            out_sig=[np.byte]\n        )\n        self.example_param = example_param\n        self.byte_count = 0\n        self.start_time = time.time()\n\n    def work(self, input_items, output_items):\n        \"\"\"Calculate and print the data rate every 5 seconds\"\"\"\n\n        # Count the number of bytes received in this work call\n        self.byte_count += len(input_items[0])\n\n        # Check the time elapsed since the start of the 5-second interval\n        current_time = time.time()\n        elapsed_time = current_time - self.start_time\n\n        if elapsed_time >= 1.0:  # Every 5 seconds\n            data_rate = self.byte_count / elapsed_time  # Calculate data rate in bytes per second\n            timestamp = time.strftime('%Y-%m-%d %H:%M:%S')\n            \n            # Print the data rate with the current timestamp\n            os.system('echo \"{} Data Rate: {:.2f} bytes/sec\" > /dev/pts/0'.format(timestamp, data_rate))\n            \n            # Reset the byte count and start time for the next interval\n            self.byte_count = 0\n            self.start_time = current_time\n\n        output_items[0][:] = input_items[0]  # Pass through the input to the output\n        return len(output_items[0])  # Return the length of the output\n\n"
    example_param: '1.0'
  states: {}
- name: limesdr_sink_0
  id: limesdr_sink
  parameters:
    allow_tcxo_dac: '0'
    calibr_bandw_ch0: 5e6
    calibr_bandw_ch1: 5e6
    channel_mode: '0'
    dacVal: '125'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: '50'
    gain_dB_ch1: '30'
    oversample: '0'
    rf_freq: 30e6
    samp_rate: samp_rate
    serial: 1D3AD634EA32BC
  states: {state: disabled}
- name: limesdr_source_0_0
  id: limesdr_source
  parameters:
    allow_tcxo_dac: '0'
    analog_bandw_ch0: 5e6
    analog_bandw_ch1: 5e6
    calibr_bandw_ch0: 5e6
    calibr_bandw_ch1: 5e6
    ch_align: 'False'
    channel_mode: '0'
    dacVal: '125'
    digital_bandw_ch0: '0'
    digital_bandw_ch1: '0'
    gain_dB_ch0: '50'
    gain_dB_ch1: '30'
    oversample: '0'
    rf_freq: 30e6
    samp_rate: samp_rate
    serial: 1D3AD634EA32BC
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    name: Before Channel
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: Rx Spectrum
    name: Rx Spectrum
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: ''
    name: Scope Plot
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: A
    bw0: 20e6
    center_freq0: 19e06
    dev_addr: ''
    gain0: '40'
    samp_rate: 10e6
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: A
    bw0: 20e6
    center_freq0: 19e06
    gain0: '40'
    samp_rate: 10e6
    stream_args: peak=0.003906
    sync: pc_clock
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: channel
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: channel
  states: {state: disabled}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_file_source_0, '0', epy_block_0_1_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', limesdr_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', virtual_sink_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_stream_to_tagged_stream_0, '0', blocks_throttle_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_ofdm_tx_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', epy_block_0_1_0_1, '0']
- [blocks_throttle_0, '0', digital_ofdm_tx_0, '0']
- [blocks_throttle_0, '0', epy_block_0_1_0_1, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [digital_ofdm_rx_0, '0', blocks_file_sink_0_0_1, '0']
- [digital_ofdm_rx_0, '0', blocks_uchar_to_float_0, '0']
- [digital_ofdm_rx_0, '0', epy_block_0_1_0, '0']
- [digital_ofdm_tx_0, '0', blocks_multiply_const_vxx_0, '0']
- [epy_block_0_1, '0', blocks_null_sink_1, '0']
- [epy_block_0_1_0, '0', blocks_null_sink_1_0, '0']
- [epy_block_0_1_0_0, '0', blocks_null_sink_1_0_0, '0']
- [epy_block_0_1_0_1, '0', blocks_null_sink_1_0_0_0, '0']
- [limesdr_source_0_0, '0', digital_ofdm_rx_0, '0']
- [limesdr_source_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [uhd_usrp_source_0, '0', digital_ofdm_rx_0, '0']
- [uhd_usrp_source_0, '0', epy_block_0_1, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0_0, '0']
- [virtual_source_0, '0', digital_ofdm_rx_0, '0']
- [virtual_source_0, '0', qtgui_freq_sink_x_0_0, '0']

metadata:
  file_format: 1
