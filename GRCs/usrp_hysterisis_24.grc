options:
  parameters:
    author: aerolifi
    generate_options: qt_gui
    id: usrp_hysterisis_24
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: connected_to
  id: variable
  parameters:
    value: '''None'''
  states: {}
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: len_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '16000'
  states: {}
- name: variable_function_probe_0
  id: variable_function_probe
  parameters:
    block_id: my_block_0
    function_name: get_number
    poll_rate: '10'
    value: '0'
  states: {}
- name: blocks_file_sink_0_0_1
  id: blocks_file_sink
  parameters:
    file: /dev/pts/2
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0_1_0
  id: blocks_file_sink
  parameters:
    file: /dev/pts/2
    type: byte
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/aerolifi/Documents/GRCs/file1.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/aerolifi/Documents/GRCs/file2.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.0175'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.38'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: len_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: len_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: digital_ofdm_rx_0
  id: digital_ofdm_rx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-8,-7,-6,-5,5,6,7,8),)
    packet_len_key: '"rx_len"'
    payload_mod: '"QPSK"'
    pilot_carriers: ((-4,-3,3,4),)
    pilot_symbols: ((-1,1,-1,1),)
    sync_word1: None
    sync_word2: None
  states: {state: disabled}
- name: digital_ofdm_rx_0_0
  id: digital_ofdm_rx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-4,-3,-2,-1,1,2,3,4),)
    packet_len_key: '"rx_len"'
    payload_mod: '"QPSK"'
    pilot_carriers: ((-6,-5,5,6),)
    pilot_symbols: ((-1,1,-1,1),)
    sync_word1: None
    sync_word2: None
  states: {state: disabled}
- name: digital_ofdm_tx_0
  id: digital_ofdm_tx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-8,-7,-6,-5,5,6,7,8),)
    packet_len_key: len_tag_key
    payload_mod: '"QPSK"'
    pilot_carriers: ((-4,-3,3,4),)
    pilot_symbols: ((-1,1,-1,1),)
    rolloff: '0'
    sync_word1: None
    sync_word2: None
  states: {}
- name: digital_ofdm_tx_0_0
  id: digital_ofdm_tx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-4,-3,-2,-1,1,2,3,4),)
    packet_len_key: len_tag_key
    payload_mod: '"QPSK"'
    pilot_carriers: ((-6,-5,5,6),)
    pilot_symbols: ((-1,1,-1,1),)
    rolloff: '0'
    sync_word1: None
    sync_word2: None
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import os


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """Print the signal power in dB to /dev/pts"""
              power_db = 10 * np.log10(np.mean(np.abs(input_items[0])**2))  # Compute power in dB
              os.system('echo "{:.2f}" > /dev/pts/4'.format(power_db))  # Write to /dev/pts/4
              output_items[0][:] = input_items[0]  # Pass through the input to the output
              return len(output_items[0])  # Return the length of the output
    example_param: '1.0'
  states: {state: disabled}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import os


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """Print the signal power in dB to /dev/pts"""
              power_db = 10 * np.log10(np.mean(np.abs(input_items[0])**2))  # Compute power in dB
              os.system('echo "{:.2f}" > /dev/pts/1'.format(power_db))  # Write to /dev/pts/5
              output_items[0][:] = input_items[0]  # Pass through the input to the output
              return len(output_items[0])  # Return the length of the output
    example_param: '1.0'
  states: {state: disabled}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport os\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, example_param=1.0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Embedded Python Block',   # will show up in GRC\n            in_sig=[np.complex64, np.complex64],\n            out_sig=[np.complex64]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.example_param = example_param\n\n    def work(self, input_items, output_items):\n        \"\"\"Print the signal power in dB to /dev/pts\"\"\"\n        #power_db_0 = 10 * np.log10(np.mean(np.abs(input_items[0])**2))  # Compute power of input 0 in dB\n        #power_db_1 = 10 * np.log10(np.mean(np.abs(input_items[1])**2))  # Compute power of input 1 in dB\n        \n        \n        #os.system('echo \"Power A: {:.2f}\" > /dev/pts/1'.format(power_db_0))  # Write to /dev/pts/4\n        #os.system('echo \"Power B: {:.2f}\" > /dev/pts/2'.format(power_db_1))\n        #power_dp_0=1\n        #power_dp_1=0\n        #out=input_items[0]\n        #out_bytes=input_items.astype(np.byte)\n        \n        out= 'A'\n        \n        '''\n        if power_db_0 - power_db_1 > 5:\n        \tout = 'Connection Established with A'  # Pass through the input 0 to the output\n        \tconnected_to = 'A'\n        elif power_db_1 - power_db_0 > 5:\n        \tout = 'Connection Established with B'  # Pass through the input 0 to the output\t\n        \tconnected_to = 'B'\n        \n        else:\n        \tout = 'Connection Retained'\n        \t#out = 'Connection Retained with {}'.format(connected_to)\n        \t\n        '''\n        \n        '''\n        if power_db_0 > power_db_1:\n        \tout = 'Connected to A \\t\\t Power A: {:.2f}  \\t\\t Power B: {:.2f}'.format(power_db_0, power_db_1)  # Pass through the input 0 to the output\n        else:\n        \tout = 'Connected to B \\t\\t Power A: {:.2f}  \\t\\t Power B: {:.2f}'.format(power_db_0, power_db_1)\n       '''\n        \n        \n        #Hard Decision Handover\n        '''\n        if power_db_0 > power_db_1:\n                out = '{:.2f} A'.format(power_db_0)  # Pass through the input 0 to the output\n        else:\n                out = '{:.2f} B'.format(power_db_1) \n        \n        '''\n        '''\n        ratio = power_db_1/power_db_0\n        if ratio < 1/1.5:\n                out = 'B\\t\\t\\t {:.2f}'.format(power_db_1)  # Pass through the input 0 to the output\n        else:\n                out = 'A\\t\\t\\t {:.2f}'.format(power_db_0)\n        '''\n                \n         \n        #No Handover algorithm      \n        '''\n        if power_db_0 > power_db_1:\n                out = '{:.2f} B'.format(power_db_1)  # Pass through the input 0 to the output\n        else:\n                out = '{:.2f} B'.format(power_db_1) \n        \n        '''\n        \t\n       \n        \n        #output_items[0][:] = out\n        os.system('echo \"{}\" > /dev/pts/1'.format(out)) \n        \t\n        return len(output_items[0])  # Return the length of the output\n        \n        \n        \n        \n"
    example_param: '1.0'
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      import os
      from gnuradio import gr


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.complex64, np.complex64],
                  out_sig=[np.complex64]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """example: multiply with constant"""
              power_db_0 = 10 * np.log10(np.mean(np.abs(input_items[0])**2))  # Compute power of input 0 in dB
              power_db_1 = 10 * np.log10(np.mean(np.abs(input_items[1])**2))  # Compute power of input 1 in dB
              out= 'A'
              
               #Hysteresis A to B
              
              ratio = power_db_1/power_db_0
              if ratio > 1.5:
                      out = '{:.2f} A'.format(power_db_0)  # Pass through the input 0 to the output
              else:
                      out = '{:.2f} B'.format(power_db_1)
              
              
              
              os.system('echo "{}" > /dev/pts/0'.format(out)) 
              
              output_items[0][:] = input_items[0] * self.example_param
              return len(output_items[0])
    example_param: '1.0'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: Rx Spectrum
    name: Rx Spectrum 0
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: Rx Spectrum
    name: Rx Spectrum 1
    showports: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"OFE 0 Signal Power"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    name: '"OFE 1 Signal Power"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: A
    ant1: A
    bw0: 1e6
    bw1: 1e6
    center_freq0: 19e06
    center_freq1: 20e06
    dev_addr: ''
    gain0: '40'
    gain1: '40'
    nchan: '2'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: A
    ant1: A
    bw0: 1e06
    bw1: 1e06
    center_freq0: 19e06
    center_freq1: 20e06
    gain0: '40'
    gain1: '40'
    nchan: '2'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_file_source_0_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', uhd_usrp_sink_0_0, '1']
- [blocks_stream_to_tagged_stream_0, '0', digital_ofdm_tx_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', digital_ofdm_tx_0_0, '0']
- [digital_ofdm_rx_0, '0', blocks_file_sink_0_0_1_0, '0']
- [digital_ofdm_tx_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_ofdm_tx_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_0_0, '0']
- [epy_block_0_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [epy_block_0_1, '0', blocks_file_sink_0_0_1, '0']
- [epy_block_0_1, '0', blocks_null_sink_1, '0']
- [epy_block_1, '0', blocks_null_sink_2, '0']
- [uhd_usrp_source_0, '0', digital_ofdm_rx_0, '0']
- [uhd_usrp_source_0, '0', epy_block_0, '0']
- [uhd_usrp_source_0, '0', epy_block_0_1, '0']
- [uhd_usrp_source_0, '0', epy_block_1, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '1', blocks_null_sink_0, '0']
- [uhd_usrp_source_0, '1', digital_ofdm_rx_0_0, '0']
- [uhd_usrp_source_0, '1', epy_block_0_0, '0']
- [uhd_usrp_source_0, '1', epy_block_0_1, '1']
- [uhd_usrp_source_0, '1', epy_block_1, '1']
- [uhd_usrp_source_0, '1', qtgui_freq_sink_x_0_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
