options:
  parameters:
    author: aerolifi
    generate_options: qt_gui
    id: usrp_2_channel_test_16
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: len_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '64000'
  states: {}
- name: blocks_complex_to_interleaved_char_0
  id: blocks_complex_to_interleaved_char
  parameters:
    scale_factor: '1.0'
    vector_output: 'False'
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /dev/pts/2
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/aerolifi/Documents/GRCs/file1.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_0_0
  id: blocks_file_source
  parameters:
    file: /home/aerolifi/Documents/GRCs/file2.txt
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_interleaved_char_to_complex_0
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {state: disabled}
- name: blocks_interleaved_char_to_complex_1
  id: blocks_interleaved_char_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {state: disabled}
- name: digital_psk_demod_0
  id: digital_psk_demod
  parameters:
    constellation_points: '2'
    differential: 'True'
    excess_bw: '0.35'
    freq_bw: 6.28/100.0
    mod_code: '"gray"'
    phase_bw: 6.28/100.0
    samples_per_symbol: '2'
    timing_bw: 6.28/100.0
  states: {}
- name: digital_psk_mod_0
  id: digital_psk_mod
  parameters:
    constellation_points: '2'
    differential: 'True'
    excess_bw: '0.35'
    mod_code: '"gray"'
    samples_per_symbol: '2'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: A
    ant1: A
    bw0: 5e6
    bw1: 5e6
    center_freq0: 20e06
    center_freq1: 40e06
    dev_addr: ''
    gain0: '40'
    gain1: '40'
    nchan: '2'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: A
    ant1: A
    bw0: 1e06
    bw1: 1e06
    center_freq0: 19e06
    center_freq1: 20e06
    gain0: '40'
    gain1: '40'
    nchan: '2'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_complex_to_interleaved_char_0, '0', blocks_file_sink_0, '0']
- [blocks_file_source_0, '0', blocks_interleaved_char_to_complex_0, '0']
- [blocks_file_source_0, '0', digital_psk_mod_0, '0']
- [blocks_file_source_0_0, '0', blocks_interleaved_char_to_complex_1, '0']
- [blocks_interleaved_char_to_complex_0, '0', uhd_usrp_sink_0_0, '0']
- [blocks_interleaved_char_to_complex_1, '0', uhd_usrp_sink_0_0, '1']
- [digital_psk_demod_0, '0', blocks_file_sink_0, '0']
- [digital_psk_mod_0, '0', uhd_usrp_sink_0_0, '0']
- [digital_psk_mod_0, '0', uhd_usrp_sink_0_0, '1']
- [uhd_usrp_source_0, '0', digital_psk_demod_0, '0']
- [uhd_usrp_source_0, '1', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
