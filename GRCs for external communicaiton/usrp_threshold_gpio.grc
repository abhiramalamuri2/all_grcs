options:
  parameters:
    generate_options: qt_gui
    id: usrp_threshold_gpio
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: fft_len
  id: variable
  parameters:
    value: '64'
  states: {}
- name: len_tag_key
  id: variable
  parameters:
    value: '"packet_len"'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: packet_len
  id: variable
  parameters:
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '64000'
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    value: '256000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: variable_constellation_1
  id: variable_constellation
  parameters:
    const_points: '[1, -1]'
    precision: '8'
    sym_map: '[0,1]'
    type: bpsk
  states: {}
- name: blocks_file_sink_0_0_1
  id: blocks_file_sink
  parameters:
    file: /dev/pts/0
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/aerolifi/Documents/GRCs for external communicaiton/input.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.05'
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_1_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: len_tag_key
    packet_len: packet_len
    type: byte
  states: {}
- name: digital_ofdm_rx_0
  id: digital_ofdm_rx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-4,-3,-2,-1,1,2,3,4),)
    packet_len_key: '"rx_len"'
    payload_mod: '"QPSK"'
    pilot_carriers: ((-6,-5,5,6),)
    pilot_symbols: ((-1,1,-1,1),)
    sync_word1: None
    sync_word2: None
  states: {}
- name: digital_ofdm_tx_0
  id: digital_ofdm_tx
  parameters:
    cp_len: fft_len//4
    fft_len: fft_len
    header_mod: '"BPSK"'
    occupied_carriers: ((-4,-3,-2,-1,1,2,3,4),)
    packet_len_key: len_tag_key
    payload_mod: '"QPSK"'
    pilot_carriers: ((-6,-5,5,6),)
    pilot_symbols: ((-1,1,-1,1),)
    rolloff: '0'
    sync_word1: None
    sync_word2: None
  states: {}
- name: epy_block_0_1
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import os



      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, example_param=1.0):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Embedded Python Block',   # will show up in GRC
                  in_sig=[np.complex64],
                  out_sig=[np.complex64]
              )
              
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.example_param = example_param

          def work(self, input_items, output_items):
              """Print the signal power in dB to /dev/pts"""
              power_db = 10 * np.log10(np.mean(np.abs(input_items[0])**2))  # Compute power in dB
              os.system('echo "{:.2f}" > /dev/pts/1'.format(power_db))  # Write to /dev/pts/4
              output_items[0][:] = input_items[0]  # Pass through the input to the output
              return len(output_items[0])  # Return the length of the output
    example_param: '1.0'
  states: {state: disabled}
- name: epy_block_0_1_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport os\nimport uhd\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block with GPIO control based on signal power\"\"\"\n\n    def __init__(self, example_param=1.0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='Embedded Python Block with GPIO control',   # will show up in GRC\n            in_sig=[np.complex64],\n            out_sig=[np.complex64]\n        )\n        # Initialize the USRP device\n        self.usrp = uhd.usrp.MultiUSRP()\n\n        # Choose an available GPIO bank, such as FP0A\n        self.gpio_bank = \"FP0A\"\n\n        # Configure GPIO direction: Set GPIO pin 0 as output\n        direction_mask = 0x01  # Set GPIO pin 0 as output\n        self.usrp.set_gpio_attr(self.gpio_bank, \"DDR\", direction_mask, direction_mask, 0)\n\n        # Initialize the GPIO pin to low\n        self.set_gpio_low()\n\n    def set_gpio_high(self):\n        \"\"\"Set GPIO pin to logic high (1)\"\"\"\n        self.usrp.set_gpio_attr(self.gpio_bank, \"OUT\", 0x01, 0x01, 0)  # Use radio index 0\n\n    def set_gpio_low(self):\n        \"\"\"Set GPIO pin to logic low (0)\"\"\"\n        self.usrp.set_gpio_attr(self.gpio_bank, \"OUT\", 0x00, 0x01, 0)  # Use radio index 0\n\n    def work(self, input_items, output_items):\n        \"\"\"Calculate the signal power and control GPIO\"\"\"\n        # Compute power in dB\n        power_db = 10 * np.log10(np.mean(np.abs(input_items[0])**2))\n\n        # Send power information to terminal\n        os.system('echo \"{:.2f}\" > /dev/pts/1'.format(power_db))\n\n        # GPIO logic: if signal power < -85 dB, set GPIO high, otherwise set low\n        if power_db < -85:\n            self.set_gpio_high()\n        else:\n            self.set_gpio_low()\n\n        # Pass through the input to the output\n        output_items[0][:] = input_items[0]\n        return len(output_items[0])  # Return the length of the output\n\n"
    example_param: '1.0'
  states: {state: disabled}
- name: snippet_0
  id: snippet
  parameters:
    code: |-
      import uhd
      import time

      # Initialize the USRP device
      usrp = uhd.usrp.MultiUSRP()

      # Choose an available GPIO bank, such as FP0A
      gpio_bank = "FP0A"

      # Configure GPIO direction
      direction_mask = 0x01  # Set GPIO pin 0 as output
      usrp.set_gpio_attr(gpio_bank, "DDR", direction_mask, direction_mask, 0)  # Use radio index 0

      # Commenting out the "OUT_EN" line to see if it's necessary
      # output_enable_mask = 0x01  # Enable GPIO pin 0 for output
      # usrp.set_gpio_attr(gpio_bank, "OUT_EN", output_enable_mask, output_enable_mask, 0)  # Use radio index 0

      # Infinite loop to toggle GPIO high and low
      try:
          while True:
              # Set the GPIO pin to logic high (1)
              usrp.set_gpio_attr(gpio_bank, "OUT", 0x01, 0x01, 0)  # Use radio index 0
              print("GPIO HIGH")
              time.sleep(1)

              # Set the GPIO pin to logic low (0)
              usrp.set_gpio_attr(gpio_bank, "OUT", 0x00, 0x01, 0)  # Use radio index 0
              print("GPIO LOW")
              time.sleep(1)

      except KeyboardInterrupt:
          print("\nExiting...")
    section: main_after_init
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: A
    bw0: 5e6
    center_freq0: 19e06
    dev_addr: ''
    gain0: '50'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: A
    bw0: 5e6
    center_freq0: 19e06
    gain0: '50'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_multiply_const_vxx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_ofdm_tx_0, '0']
- [digital_ofdm_rx_0, '0', blocks_file_sink_0_0_1, '0']
- [digital_ofdm_tx_0, '0', blocks_multiply_const_vxx_0, '0']
- [epy_block_0_1, '0', blocks_null_sink_1, '0']
- [epy_block_0_1_0, '0', blocks_null_sink_1_0, '0']
- [uhd_usrp_source_0, '0', digital_ofdm_rx_0, '0']
- [uhd_usrp_source_0, '0', epy_block_0_1, '0']
- [uhd_usrp_source_0, '0', epy_block_0_1_0, '0']

metadata:
  file_format: 1
